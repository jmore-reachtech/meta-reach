PRINC := "${@int(PRINC) + 2}"

COMPATIBLE_MACHINE += "g2c1"
