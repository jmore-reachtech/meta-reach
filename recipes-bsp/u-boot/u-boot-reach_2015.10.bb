require recipes-bsp/u-boot/u-boot-fslc.inc

SRCREV = "8d53df8776da7ada578143bab2da5561f972601b"
SRC_URI = "git://github.com/jmore-reachtech/reach-imx-u-boot.git;branch=reach-${PV};protocol=git"
