INITSCRIPT_PARAMS_${PN} = "remove"

