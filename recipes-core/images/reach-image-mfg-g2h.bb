require recipes-core/images/reach-image-mfg.inc

REACH_MFG_TEST_PACKAGE = "\
	mfg-test-g2h \
	mfg-test-g2h-splash \
	mfg-test-g2h-printk \
	alsa-utils \
	canutils \
"

COMPATIBLE_MACHINE = "(g2h)"
