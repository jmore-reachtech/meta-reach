SRC_URI += "http://museum.php.net/php5/php-5.4.14.tar.bz2"

PRINC = "1"
