FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

SRC_URI += "file://0001-Pear-version-1.10.3-breaks-php-install.patch \
"
