LIC_FILES_CHKSUM = "file://include/linux/can.h;endline=43;md5=a6b6c0dcc6ff5e00989430eac32bd842"

SRCREV = "9ae877ce3215a748729f15167c943cd8338a9a60"

