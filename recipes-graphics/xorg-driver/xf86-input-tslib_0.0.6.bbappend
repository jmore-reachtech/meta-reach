SRC_URI += "file://0001-Remove-old-Xf86-input-call.patch \
"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
