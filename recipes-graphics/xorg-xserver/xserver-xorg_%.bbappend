EXTRA_OECONF_append_mxs = "--enable-kdrive \
                 --enable-xfbdev \
                 --enable-tslib \
"

DEPENDS_append_mxs = " tslib \
"
