EXTRA_OECONF += "--enable-kdrive \
                 --enable-xfbdev \
"
