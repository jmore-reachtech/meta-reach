EXTRA_OECONF_append_g2c = "--enable-kdrive \
                 --enable-xfbdev \
                 --enable-tslib \
"

DEPENDS_append_g2c = " tslib \
"
