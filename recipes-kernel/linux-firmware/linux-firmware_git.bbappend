PACKAGES =+ "${PN}-ar9271"

FILES_${PN}-ar9271 = " \
  /lib/firmware/ar9271.fw \
"

