# Copyright (C) 2019 Reach Technology.

RDEPENDS_${PN} += " \
    nativesdk-qtdeclarative-tools \
"
