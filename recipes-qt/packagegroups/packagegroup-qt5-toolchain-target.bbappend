# Copyright (C) 2019 Reach Technology.

# We don't want to build qtwebkit
USE_RUBY = ""

