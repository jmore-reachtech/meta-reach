PACKAGECONFIG_append = " sql-sqlite tslib"
QT_CONFIG_FLAGS += " -qpa eglfs"
